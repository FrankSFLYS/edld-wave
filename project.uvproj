# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: edld-wave +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./src/: delay.c key.c main.c pcf8591.c timer.c
